## drivers/net/wireless/wl12xx_prekm/Kconfig
```kconfig
config WL12XX_PREKM
	tristate
	default m
	---help---
	  pre-kernel memory for wifi
```
